# Repository jhyland87/Cryocooler-Controller (continued)

## KiCad design hardware/kicad/cryocooler.kicad_pcb (continued)

Schematic: rails_15v.kicad_sch, Rails +-15V

Parts:
C11, C12: 10uF; C_0805_2012Metric
C40: 100nF; C_0402_1005Metric
C49, C50: 1uF; C_0603_1608Metric
C55: 68nF; C_0603_1608Metric
C56, C61, C62: 22uF/25V X7R; C_1210_3225Metric
C79: 47nF; C_0603_1608Metric
D4, D5: DFLS240; D_PowerDI-123
L2: SRP7050TA-3R3M; L_Bourns_SRP7050TA
L3: SRP7050TA-6R8M; L_Bourns_SRP7050TA
R68: 5.6k; R_0402_1005Metric
R69: 12k; R_0402_1005Metric
R70: 2.67M; R_0402_1005Metric
R71: 137k; R_0402_1005Metric
R72: 2.55M; R_0402_1005Metric
R73: 118k; R_0402_1005Metric
U20: ADP5071ACPZ; LFCSP-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm

Connections:
+5V_PS15: C11.1, C12.1, C40.1, U20.7 (EN1), U20.9 (EN2), U20.15 (PVIN1), U20.16 (PVINSYS), U20.17 (PVIN2); also elsewhere on the board
+16V5: C56.1, D4.1 (K), R70.1; also elsewhere on the board
-16V5: C61.1, C62.1, D5.2 (A), R72.1; also elsewhere on the board
GND: C11.2, C12.2, C40.2, C49.2, C50.2, C55.2, C56.2, C61.2, C62.2, C79.2, L3.2, R71.2, U20.2 (SYNC), U20.4 (SLEW), U20.13 (AGND), U20.19 (PGND), U20.21 (EP); also elsewhere on the board
unnamed: C55.1, R69.1
unnamed: C79.1, R68.1
unnamed: D4.2 (A), L2.2, U20.20 (SW1)
unnamed: D5.1 (K), L3.1, U20.18 (SW2)
unnamed: R68.2, U20.6 (COMP1)
unnamed: R69.2, U20.10 (COMP2)
unnamed: R70.2, R71.1, U20.5 (FB1)
unnamed: R72.2, R73.1, U20.11 (FB2)
unnamed: L2.1, U20.1 (INBK)
unnamed: C49.1, U20.3 (SEQ), U20.14 (VREG)
unnamed: C50.1, R73.2, U20.12 (VREF)

Notes on the sheet:
ADP5071 layout: keep PGND off the exposed pad on the top layer (datasheet layout section). SEQ on VREG starts both channels together when EN2 rises.
ADP5071 values from datasheet Fig. 47 / Tables 9-11.
ADP5071 DECOUPLING CAPACITORS
ADP5071ACPZ (5 V in): +16.4 V boost and -16.5 V inverting rails for the two post-regulators on the Regulators +-15V sheet.
ADP5071 +-16.5 V CONVERTER

Schematic: expansion.kicad_sch

Parts:
C434, C435, C436, C437, C438: 100nF; C_0402_1005Metric
J34: RS-485 (A / B / GND / NC); JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J35: SPI EXPANSION; JST_PH_B10B-PH-SM4-TB_1x10-1MP_P2.00mm_Vertical
JP11: RS485 TERM; R_0603_1608Metric; not fitted
Q100: CSD17381F4; Texas_FemtoFET_F4_1.0x0.6mm
R640, R641, R648: 10k; R_0402_1005Metric
R642: 120; R_1206_3216Metric
R643, R644, R645, R646: 100; R_0402_1005Metric
R647: 1k; R_0402_1005Metric
R649: 100k; R_0402_1005Metric
U110: SC16IS750IBS; HVQFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U111: THVD2410DRBR; VSON-8-1EP_3x3mm_P0.65mm_EP1.65x2.4mm
U112: ECS-2520MV-160-BN-TR; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm
U113, U114: SN74LVC1G125DRYR; Texas_USON-6_1x1.45mm_P0.5mm_SMD

Connections:
+3V3: C434.1, C435.1, C436.1, C437.1, C438.1, J35.1, R640.1, R641.1, R647.1, R648.1, U110.4 (VDD), U111.8 (VCC), U112.1 (Tri-State), U112.4 (VDD), U113.6 (VCC), U114.6 (VCC); also elsewhere on the board
+5V: J35.2; also elsewhere on the board
/ESP_EN: U110.1 (~RESET); also elsewhere on the board
/Expansion/EXP_MISO: J35.5, R649.1, U113.2 (A), U114.2 (A)
/Expansion/EXP_MOSI: J35.4, R644.2
/Expansion/EXP_SCK: J35.3, R643.2
/Expansion/UART_CLK: U110.2 (XTAL1), U112.3 (OUT)
/Expansion/~EXP_CSA: J35.7, R645.2
/Expansion/~EXP_CSB: J35.8, R646.2
/Expansion/~RS485_RTS: Q100.1 (G), U110.21 (~RTS)
/~EXP_CS_A: R645.1, U113.1 (~OE); also elsewhere on the board
/~EXP_CS_B: R646.1, U114.1 (~OE); also elsewhere on the board
/~EXP_INT: J35.6, R648.2; also elsewhere on the board
/~RS485_CS: U110.6 (~CS); also elsewhere on the board
/~RS485_IRQ: R647.2, U110.11 (~IRQ); also elsewhere on the board
GND: C434.2, C435.2, C436.2, C437.2, C438.2, J34.3, J35.9, J35.10, Q100.2 (S), R649.2, U110.5 (I2C/~SPI), U110.10 (VSS), U110.16 (VSS), U110.22 (~CTS), U110.25 (EP), U111.5 (GND), U111.9 (EP), U112.2 (GND), U113.3 (GND), U114.3 (GND); also elsewhere on the board
unnamed: J34.1, R642.1, U111.6 (A)
unnamed: J34.2, JP11.1 (A), U111.7 (B)
unnamed: JP11.2 (B), R642.2
unnamed: Q100.3 (D), R641.2, U111.2 (~RE), U111.3 (DE)
unnamed: R640.2, U110.24 (RX), U111.1 (R)
unnamed: U110.23 (TX), U111.4 (D)
SPI_MISO: U110.8 (SO), U113.4 (Y), U114.4 (Y); also elsewhere on the board
SPI_MOSI: R644.1, U110.7 (SI); also elsewhere on the board
SPI_SCK: R643.1, U110.9 (SCLK); also elsewhere on the board

Notes on the sheet:
THVD2410 DECOUPLING CAPACITOR
100 R in series with every line the board drives
SC16IS750 AND CLOCK DECOUPLING CAPACITORS
UART CLOCK
RS-485 / MODBUS PORT
SPI EXPANSION HEADER
MISO BUFFER DECOUPLING CAPACITORS
RTS goes low while sending, and the FET turns that into DE high. After reset RTS is high, so the driver is off. CTS and the bridge GPIOs are unused.
RS-485: SC16IS750 (SPI mode 0 only, 4 MHz max) with the same 16 MHz oscillator as the signal generator: 9600, 19200 and 38400 baud are 0.16 % off; 57600 (2.1 %) and 115200 (3.5 %) are not usable. Direction: EFCR.RTSCON = 1, RTSINVER = 0.
SPI expansion header: 1 +3V3, 2 +5V, 3 SCK, 4 MOSI, 5 MISO, 6 INT (active low, to the I/O expander), 7 CS A, 8 CS B, 9 and 10 GND. MISO reaches the bus only while a chip select is low.
THVD2410: fail-safe receiver, +-70 V bus fault, +-12 kV IEC ESD, so no bias resistors and no extra clamp. Fit the jumper to end the bus with 120 R here.

Schematic: power_good.kicad_sch, Power Good

Parts:
D11: PG +15V G=good R=bad; LED_Kingbright_APGB0607
D12: PG -15V G=good R=bad; LED_Kingbright_APGB0607
D15: BAT54AW; SOT-323_SC-70
Q22, Q23, Q24, Q51, Q52: BSS138; SOT-323_SC-70
Q42: BSS138W; SOT-323_SC-70
R13: 10k; R_0402_1005Metric
R52: 1k; R_0402_1005Metric
R57, R58: 220k; R_0402_1005Metric
R83, R84: 2.2k; R_0402_1005Metric
R86, R87: 62k; R_0402_1005Metric
R88, R89, R90: 470k; R_0402_1005Metric
R402, R404: 100k; R_0402_1005Metric
R403, R405: 1.5k; R_0402_1005Metric

Connections:
+3V3: R13.1, R88.2, R402.1, R403.1, R404.1, R405.1; also elsewhere on the board
+5V: R83.1, R84.1; also elsewhere on the board
+15V: R57.1, R58.1, R89.1; also elsewhere on the board
-15V: R90.2; also elsewhere on the board
/PGN_15V: D15.2, Q24.1 (G), Q42.3 (D), R58.2, R87.1; also elsewhere on the board
/PGP_15V: D15.1, Q23.1 (G), R57.2, R86.1; also elsewhere on the board
/PG_15V: D15.3, Q22.1 (G), R88.1; also elsewhere on the board
/Power Good/PGN_LED_GA: D12.1 (GA), R84.2
/Power Good/PGN_LED_GK: D12.2 (GK), Q24.3 (D), Q52.1 (G), R404.2
/Power Good/PGN_LED_RA: D12.4 (RA), R405.2
/Power Good/PGN_LED_RK: D12.3 (RK), Q52.3 (D)
/Power Good/PGP_LED_GA: D11.1 (GA), R83.2
/Power Good/PGP_LED_GK: D11.2 (GK), Q23.3 (D), Q51.1 (G), R402.2
/Power Good/PGP_LED_RA: D11.4 (RA), R403.2
/Power Good/PGP_LED_RK: D11.3 (RK), Q51.3 (D)
/~PG_15V: R52.2; also elsewhere on the board
GND: Q22.2 (S), Q23.2 (S), Q24.2 (S), Q42.2 (S), Q51.2 (S), Q52.2 (S), R86.2, R87.2; also elsewhere on the board
unnamed: Q22.3 (D), R13.2, R52.1
unnamed: Q42.1 (G), R89.2, R90.1

Notes on the sheet:
PG_15V = the two nodes ANDed by a BAT54AW with a 470k pull-up to +3V3 (weak so it cannot lift dead nodes; 3.3 V only when both are good); it gates the amplifier REM switch and reads LOW on GPIO43 (~{PG_15V}) when both rails are good.
-15 V GUARD: an unpowered LT3094 cannot pull PGN low.
Midpoint near 0 V with both rails up, about +7.5 V with -15 V missing.
+15 V GOOD: NODE AND LED
PGP and PGN pull their own node low when bad. Each node is the +15 V rail through 220k/62k (about 3.2 V when good, under 0.3 V if its pin pulls low or the rail is missing) and lights its LED green, or red when low.
ACTIVE-LOW FLAG TO THE ESP32
BOTH GOOD (AND)
-15 V GOOD: NODE AND LED

Schematic: imu.kicad_sch

Parts:
J14: 505448-0891; Molex_Micro-Lock_Plus_505448-0891_2x04_P1.25mm_Horizontal
U36: NUF6401MNT1G; OnSemi_DFN-12-1EP_506AD

Connections:
+3V3: J14.4 (+3V3); also elsewhere on the board
/IMU_INT1: U36.2 (CH2); also elsewhere on the board
/IMU_INT2: U36.1 (CH1); also elsewhere on the board
/~IMU_CS: U36.4 (CH4); also elsewhere on the board
GND: J14.2 (GND), U36.13 (GND); also elsewhere on the board
unnamed: J14.7 (INT1), U36.11 (CH2)
unnamed: J14.8 (INT2), U36.12 (CH1)
unnamed: J14.6 (MISO), U36.10 (CH3)
unnamed: J14.3 (MOSI), U36.8 (CH5)
unnamed: J14.1 (SCK), U36.7 (CH6)
unnamed: J14.5 (~CS), U36.9 (CH4)
SPI_MISO: U36.3 (CH3); also elsewhere on the board
SPI_MOSI: U36.5 (CH5); also elsewhere on the board
SPI_SCK: U36.6 (CH6); also elsewhere on the board

Notes on the sheet:
Module Vin = +3V3 keeps its logic at 3.3 V. NUF6401MN filter: 100 R in series to damp the cable, 17 pF and an ESD clamp on each side of all six signals.
J14 pin -> module pad: 1 SCL, 2 GND, 3 SDA, 4 Vin, 5 CS, 6 DO, 7 I1, 8 I2 (3Vo pad open). Keep the cable short and twist SCK with GND (pins 1-2 sit one above the other).
IMU CABLE (J14) AND FILTER
LSM6DSOX is the off-board Adafruit module (product 4438) on the cooler, cabled to J14 (Molex Micro-Lock Plus 2x4, 1.25 mm) over the main SPI bus (CS from the decoder, INT1 GPIO2 single-tap, INT2 GPIO39 wake-up).

Schematic: amp_current.kicad_sch, Amp Current

Parts:
C6: 22uF/10V; C_1206_3216Metric
C7: 10uF; C_0805_2012Metric
C31, C52, C53, C301, C302: 100nF; C_0402_1005Metric
C45: 1uF; C_0603_1608Metric
J11: AMP OUT (+ / -); TE_2305908-2_1x02_P5.00mm_Horizontal_SMD
J12: CRYOCOOLER (+ / - / GND); TE_643228-1_1x03_P6.35mm_Horizontal
R63: 4.02k; R_0603_1608Metric
R64, R65, R66, R67: 1M; R_1206_3216Metric
R501: 10k; R_0402_1005Metric
U17: ISOW7841AQDWERQ1; SOIC-16W_7.5x10.3mm_P1.27mm
U18: ACS37800KMACTR-015B5-SPI; SOIC-16W_7.5x10.3mm_P1.27mm
U41, U42: SN74LVC1G125DRYR; Texas_USON-6_1x1.45mm_P0.5mm_SMD

Connections:
+3V3: C301.1, C302.1, R501.1, U41.6 (VCC), U42.6 (VCC); also elsewhere on the board
+3V3_ISO: C6.1, C52.1, U17.1 (VCC); also elsewhere on the board
/Amp Current/ACS_MISO: U17.6 (OUTD), U42.2 (A)
/Amp Current/ACS_SCK: R501.2, U17.4 (INB), U41.4 (Y)
/~ACS_CS: U17.5 (INC), U41.1 (~OE), U42.1 (~OE); also elsewhere on the board
GND: C6.2, C52.2, C301.2, C302.2, J12.3, U17.2 (GND1), U17.8 (GND1), U41.3 (GND), U42.3 (GND); also elsewhere on the board
ISO_5V: C7.1, C31.1, C45.1, C53.1, U17.10 (SEL), U17.16 (VISO), U18.13 (VCC); also elsewhere on the board
ISO_GND: C7.2, C31.2, C45.2, C53.2, J11.2, J12.2, R63.2, U17.9 (GND2), U17.15 (GND2), U18.14 (GND), U18.15 (VINN); also elsewhere on the board
unnamed: J11.1, U18.1 (IP+), U18.2 (IP+), U18.3 (IP+), U18.4 (IP+)
unnamed: J12.1, R67.2, U18.5 (IP-), U18.6 (IP-), U18.7 (IP-), U18.8 (IP-)
unnamed: R64.2, R65.1
unnamed: R65.2, R66.1
unnamed: R66.2, R67.1
unnamed: U17.11 (IND), U18.12 (MISO)
unnamed: U17.14 (OUTA), U18.10 (MOSI)
unnamed: U17.13 (OUTB), U18.11 (SCLK)
unnamed: U17.12 (OUTC), U18.9 (~CS)
unnamed: R63.1, R64.1, U18.16 (VINP)
SPI_MISO: U42.4 (Y); also elsewhere on the board
SPI_MOSI: U17.3 (INA); also elsewhere on the board
SPI_SCK: U41.2 (A); also elsewhere on the board

Notes on the sheet:
V / I MONITOR
Amplifier output V/I monitor: ACS37800 (SPI, 15 mA max) on an isolated 5 V domain from the ISOW7841A (SEL on VISO selects 5 V). It runs from +3V3_ISO because its one supply pin also sets the logic thresholds; 3.3 V in gives 40 mA at 5 V out.
ISOW7841 VCC DECOUPLING CAPACITORS
ACS37800 DECOUPLING CAPACITORS
SPI GATES (LOGIC SIDE)
AMPLIFIER AND COOLER TERMINALS
~{ACS_CS} comes from the CS decoder, which holds it high at reset.
VSENSE DIVIDER
ISOLATOR AND 5 V SUPPLY
Mains-class creepage/clearance applies between ISO_GND domain and the logic side on the PCB. No F suffix: the isolated outputs go high (CS inactive, SCK idle) if the logic side loses power.
The ACS37800 and the isolator drive MISO all the time, so MISO reaches the shared bus only while ~{ACS_CS} is low. SCK is gated the same way, so bus traffic for other devices never clocks the ACS37800.
ISOW7841 VISO DECOUPLING CAPACITORS
SN74LVC1G125 DECOUPLING CAPACITORS

Schematic: power_button.kicad_sch, Power Button

Parts:
C24: 100nF; C_0402_1005Metric
C41: 1uF; C_0603_1608Metric
C80: 47nF; C_0603_1608Metric
C84: 470nF; C_0805_2012Metric
C400: 2.2uF; C_0805_2012Metric
D7: STATUS G=on R=standby; LED_Kingbright_APGB0607
D17: BZT52C15; D_SOD-123
D100: 1N4148W; D_SOD-123
JP10: AUTO ON; R_0603_1608Metric; not fitted
Q1: AONR21307; AOS_DFN3x3A_8L_EP1
Q41: BSS138; SOT-23
R7, R8, R20: 10k; R_0402_1005Metric
R27: 100k; R_0402_1005Metric
R56: 220k; R_0402_1005Metric
R59: 82k; R_0402_1005Metric
R93: 13k; R_0402_1005Metric
R401: 2.2k; R_0402_1005Metric
SW3: POWER; SW_TE_1571300-2
U11: LTC2954CDDB-2; DFN-8-1EP_2x3mm_P0.5mm_EP0.61x2.2mm
U12: LM4040DBZ-5; SOT-23
U34: TPD1E05U06DPYR; Texas_DPY0002A_0.6x1mm_P0.65mm

Connections:
+3V3: Q41.1 (G), R8.2; also elsewhere on the board
+5V: R401.1; also elsewhere on the board
/Power Button/STATUS_GA: D7.1 (GA), R401.2
/Power Button/STATUS_RA: D7.4 (RA), Q41.3 (D), R93.2
/~PWR_BTN: JP10.1 (A), SW3.1, U11.3 (~PB), U34.1 (IO); also elsewhere on the board
/~PWR_INT: R8.1, U11.8 (~INT); also elsewhere on the board
/~PWR_KILL: R7.2; also elsewhere on the board
GND: C24.2, C41.2, C400.2, D7.2 (GK), D7.3 (RK), Q41.2 (S), SW3.2, U11.1 (GND), U11.9 (EP), U12.2 (A), U34.2 (GND); also elsewhere on the board
unnamed: C80.1, C84.2, D17.2 (A), Q1.4 (G), R20.2, R27.2
unnamed: C400.1, D100.2 (A), JP10.2 (B)
unnamed: C41.1, U11.6 (PDT)
unnamed: R20.1, U11.7 (~EN)
unnamed: R7.1, R56.2, U11.5 (~KILL)
unnamed: R56.1, R59.2, U12.1 (K)
VIN: C24.1, C84.1, D17.1 (K), D100.1 (K), Q1.1 (S), Q1.2 (S), Q1.3 (S), R27.1, R59.1, R93.1, U11.4 (VIN); also elsewhere on the board
VSW: C80.2, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D); also elsewhere on the board

Notes on the sheet:
Q1 gate: 10k series and 47 nF to the drain limit the ramp to about 20 V/ms; 470 nF to the source holds Vgs under 1.1 V on a hot plug (10 x Cgd); the Zener caps Vgs at 15 V for input transients up to the 26 V TVS clamp.
Fit the jumper to switch on as soon as 12 V arrives. PB then stays low for roughly 80-500 ms (2.2 uF on the 100k pull-up to 1.9 V), longer than the 32 ms turn-on debounce. Holding the button still forces power off.
LTC2954 DECOUPLING CAPACITORS
PUSH-BUTTON CONTROLLER
AUTO POWER-ON (OPTIONAL, NOT BENCH TESTED)
12 V LOAD SWITCH
Assumed, not verified: the LTC2954 accepts PB low from power-up as a turn-on (its datasheet describes a high-to-low transition). Try it on a rev 4 board with a capacitor across SW3 first.
LTC2954-2: tap ~{PB} = on, hold = off. ~{EN} drives the P-FET gate; ~{KILL} from GPIO10 (active low, 100 ms pulse). ~{INT} tells GPIO1 to shut down cleanly; holding ~{PB} cuts power about 6.4 s later (1 uF on PDT).
STATUS LED: red = standby (about 0.8 mA from VIN, off when +3V3 is up), green = on (+5V, about 1 mA), both = +3V3 missing

Schematic: gpio_expander.kicad_sch, GPIO Expander

Parts:
C35: 100nF; C_0402_1005Metric
U25: MCP23S08-E/ML; QFN-20-1EP_4x4mm_P0.5mm_EP2.7x2.7mm

Connections:
+3V3: C35.1, U25.4 (~RESET), U25.18 (VDD); also elsewhere on the board
/PGN_15V: U25.10 (GP1); also elsewhere on the board
/PGP_15V: U25.9 (GP0); also elsewhere on the board
/~AMBIENT_CT: U25.12 (GP3); also elsewhere on the board
/~AMBIENT_INT: U25.11 (GP2); also elsewhere on the board
/~EXPANDER_CS: U25.5 (~CS); also elsewhere on the board
/~INA239_ALERT: U25.15 (GP6); also elsewhere on the board
/~IO_ADC_DRDY: U25.14 (GP5); also elsewhere on the board
/~IO_EXP_INT: U25.13 (GP4); also elsewhere on the board
GND: C35.2, U25.2 (A1), U25.3 (A0), U25.17 (VSS), U25.21 (EP); also elsewhere on the board
SPI_MISO: U25.1 (SO); also elsewhere on the board
SPI_MOSI: U25.20 (SI); also elsewhere on the board
SPI_SCK: U25.19 (SCK); also elsewhere on the board

Notes on the sheet:
MCP23S08: SPI mode 0 slave on the main bus (CS from the decoder). SO releases within 100 ns of CS rising (datasheet Fig. 2-6, parameter 14), so it shares SPI_MISO without a buffer. A1/A0 low: opcodes 0x40 / 0x41.
All pins power up as inputs. RESET, A1 and A0 must be biased (datasheet Table 1-1). Exposed pad to VSS, in addition to pin 17. GP7 is spare; firmware enables a weak pull-up on it.
The ADT7320 INT and CT outputs drive GP2 and GP3, the universal I/O expander interrupt GP4 and the I/O ADC data-ready GP5.
MCP23S08 DECOUPLING CAPACITOR

Schematic: system_current.kicad_sch, System Current

Parts:
C32: 100nF; C_0402_1005Metric
C46: 1uF; C_0603_1608Metric
C66: 100uF/25V; CP_Elec_8x10
C68: 100nF; C_0805_2012Metric
C83: 470nF; C_0805_2012Metric
D6: ALERT (red); LED_Kingbright_APHHS1005
R9: 10k; R_0402_1005Metric
R78: 10m; R_Shunt_Vishay_WSK2512_6332Metric_T1.19mm
R79, R80: 49.9; R_0402_1005Metric
R81: 1.5k; R_0402_1005Metric
U23: INA239AIDGSR; TSSOP-10_3x3mm_P0.5mm

Connections:
+3V3: C32.1, C46.1, R9.2, R81.1, U23.6 (VS); also elsewhere on the board
+12V: C66.1, C68.1, R78.1, U23.8 (VBUS); also elsewhere on the board
/System Current/ALERT_LED_A: D6.2 (A), R81.2
/~INA239_ALERT: D6.1 (K), R9.1, U23.3 (~ALERT); also elsewhere on the board
/~INA239_CS: U23.1 (~CS); also elsewhere on the board
GND: C32.2, C46.2, C66.2, C68.2, U23.7 (GND); also elsewhere on the board
unnamed: R78.2, R79.1
unnamed: R78.3, R80.1
unnamed: C83.2, R80.2, U23.10 (IN+)
unnamed: C83.1, R79.2, U23.9 (IN-)
SPI_MISO: U23.4 (SDO); also elsewhere on the board
SPI_MOSI: U23.2 (SDI); also elsewhere on the board
SPI_SCK: U23.5 (SCLK); also elsewhere on the board
VSW: R78.4; also elsewhere on the board

Notes on the sheet:
INA239 monitors the switched 12 V rail: 10 mOhm 4-terminal shunt (1 W at 10 A), SPI mode 1 on the main bus (CS from the decoder), +/-163.84 mV range (16.4 A). ALERT drives its LED and MCP23S08 GP6.
INA239 CURRENT MONITOR
ALERT LED
INA239 DECOUPLING CAPACITORS
12 V SHUNT

Schematic: compressor_relay.kicad_sch, Compressor Relay

Parts:
D3: COMP_RELAY G=on R=off; LED_Kingbright_APGB0607
D14: 1N4148W; D_SOD-123
J13: COMPRESSOR RELAY / GND; XKB_X2510WRS-02-9TSN_1x02_P2.54mm_Horizontal
Q7: BSS138; SOT-23
Q8: BSS84; SOT-23
R30, R31: 100k; R_0402_1005Metric
R45: 4.7k; R_0402_1005Metric
R51: 1k; R_0402_1005Metric
R61: 2.2k; R_0402_1005Metric

Connections:
+5V: R61.1; also elsewhere on the board
+12V: Q8.2 (S), R31.1; also elsewhere on the board
/COMP_RELAY_EN: R51.1; also elsewhere on the board
/Compressor Relay/COMP_RELAY: D3.1 (GA), D3.3 (RK), D14.1 (K), J13.1, Q8.3 (D), R45.1
/Compressor Relay/COMP_RELAY_LED: D3.2 (GK), D3.4 (RA), R61.2
GND: D14.2 (A), J13.2, Q7.2 (S), R30.2, R45.2; also elsewhere on the board
unnamed: Q7.3 (D), Q8.1 (G), R31.2
unnamed: Q7.1 (G), R30.1, R51.2

Notes on the sheet:
RELAY HIGH-SIDE SWITCH
COMP_RELAY_EN (GPIO16) high -> +12 V on the compressor relay terminal (BSS84 high-side switch, 130 mA max: drive an external relay or SSR coil). Flyback diode across the output. LED: green = on, red = off.
RELAY STATE LED

Schematic: aux_header.kicad_sch, AUX Header

Parts:
J40: AUX HEADER; JST_PH_B5B-PH-SM4-TB_1x05-1MP_P2.00mm_Vertical
J41: QWIIC / STEMMA QT; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
R692, R694: 100; R_0402_1005Metric
R693, R695: 4.7k; R_0402_1005Metric; not fitted
U123, U124: TPD1E05U06DPYR; Texas_DPY0002A_0.6x1mm_P0.65mm

Connections:
+3V3: J40.2, J41.2, R693.1, R695.1; also elsewhere on the board
+5V: J40.1; also elsewhere on the board
/AUX Header/AUX11_HDR: J40.3, J41.3, R692.2, R693.2, U123.1 (IO)
/AUX Header/AUX13_HDR: J40.4, J41.4, R694.2, R695.2, U124.1 (IO)
/AUX_IO11: R692.1; also elsewhere on the board
/AUX_IO13: R694.1; also elsewhere on the board
GND: J40.5, J41.1, U123.2 (GND), U124.2 (GND); also elsewhere on the board

Notes on the sheet:
AUX header: 1 +5V, 2 +3V3, 3 GPIO11, 4 GPIO13, 5 GND. Both pins are touch (T11, T13) and ADC2 inputs; ADC2 is not usable while WiFi is on.
AUX AND QWIIC HEADERS: GPIO11 AND GPIO13
Qwiic / STEMMA QT J41 (JST SH): 1 GND, 2 +3V3, 3 SDA = GPIO11, 4 SCL = GPIO13, on the same lines as J40. For I2C fit the two 4.7k pull-ups unless the module has its own.
UART, I2C, 1-Wire, touch or GPIO

Schematic: debug.kicad_sch

Parts:
D10: ISO 5V (green); LED_Kingbright_APHHS1005
R38: 3.3k; R_0402_1005Metric
TP9: +15V; TestPoint_Pad_D1.0mm
TP10: -15V; TestPoint_Pad_D1.0mm
TP11: +16V5; TestPoint_Pad_D1.0mm
TP12: -16V5; TestPoint_Pad_D1.0mm
TP14: GND; TestPoint_Keystone_5015_Micro_Mini
TP37: DDS; TestPoint_Pad_D1.0mm
TP38: SINE; TestPoint_Pad_D1.0mm

Connections:
+15V: TP9.1; also elsewhere on the board
+16V5: TP11.1; also elsewhere on the board
-15V: TP10.1; also elsewhere on the board
-16V5: TP12.1; also elsewhere on the board
/DDS_SINE: TP37.1; also elsewhere on the board
/Debug/ISO_5V_LED_A: D10.2 (A), R38.2
/SIG_SINE: TP38.1; also elsewhere on the board
GND: TP14.1; also elsewhere on the board
ISO_5V: R38.1; also elsewhere on the board
ISO_GND: D10.1 (K); also elsewhere on the board

Notes on the sheet:
ANALOG AND SENSORS
ISO 5V RAIL LED
Debug aids: test points (pad per net, loops for ground) and rail LEDs. Each test point sits on a sheet pin or power symbol; the PCB generator places it beside a pad on the same net.
POWER RAILS
GROUND (scope loops)

Schematic: ambient.kicad_sch, Ambient Temp

Parts:
C305: 100nF; C_0402_1005Metric
R511, R512: 10k; R_0402_1005Metric
U50: ADT7320UCPZ; UQFN-16-1EP_4x4mm_P0.65mm_EP2.6x2.6mm

Connections:
+3V3: C305.1, R511.1, R512.1, U50.12 (VDD); also elsewhere on the board
/~AMBIENT_CS: U50.4 (~CS); also elsewhere on the board
/~AMBIENT_CT: R512.2, U50.10 (~CT); also elsewhere on the board
/~AMBIENT_INT: R511.2, U50.9 (~INT); also elsewhere on the board
GND: C305.2, U50.11 (GND), U50.17 (EP); also elsewhere on the board
SPI_MISO: U50.2 (DOUT); also elsewhere on the board
SPI_MOSI: U50.3 (DIN); also elsewhere on the board
SPI_SCK: U50.1 (SCLK); also elsewhere on the board

Notes on the sheet:
INT and CT are open drain and need 10 k pull-ups; they go to expander GP2 and GP3. Place this part far from anything that warms the board.
ADT7320 DECOUPLING CAPACITOR
ADT7320: SPI mode 3 (SCLK idles high), MSB first, on the main bus (CS from the decoder). DOUT is released within 80 ns of CS rising (datasheet Table 2, t7), so it shares SPI_MISO without a buffer. Pins 5-8 and 13-16 are not bonded: left open. Exposed pad to GND.

Schematic: cooling.kicad_sch, Water Cooling

Parts:
C23: 100nF; C_0402_1005Metric
C76, C77: 22uF/25V; C_1210_3225Metric
F3: MF-MSMF050/24X; Bourns_MF-MSMF_1812_4532Metric
F4: MF-MSMF250/16X; Bourns_MF-MSMF_1812_4532Metric
J3: FAN (4-pin PWM); XKB_X2510WRS-04-9TSN_1x04_P2.54mm_Horizontal
J4: PUMP (4-pin PWM); XKB_X2510WRS-04-9TSN_1x04_P2.54mm_Horizontal
J5: ALPHACOOL ES FLOW (pin 4 NC); XKB_X2510WRS-04-9TSN_1x04_P2.54mm_Horizontal
J6: ALPHACOOL ES NTC 10k; XKB_X2510WRS-02-9TSN_1x02_P2.54mm_Horizontal
Q61: BSS138DW; SOT-363_SC-70-6
R6, R15, R16: 10k; R_0402_1005Metric
R43: 4.7k; R_0402_1005Metric
R53, R54: 1k; R_0402_1005Metric
RN1: 4.7k; R_Array_Convex_4x0402
RN2: 10k; R_Array_Convex_4x0402
U33: SP3422-04UTG; Littelfuse_DFN-5_1.0x0.6mm_P0.35mm

Connections:
+3V3: R15.1, R16.1; also elsewhere on the board
+3V3_COOL: R6.1, RN1.6 (R3.2), RN1.8 (R1.2), RN2.4 (R4.1), RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN2.8 (R1.2); also elsewhere on the board
+12V: F3.2, F4.2, J5.2; also elsewhere on the board
+12V_FAN: C76.1, F3.1, J3.2
+12V_PUMP: C77.1, F4.1, J4.2
/FAN_PWM: R15.2, R53.1; also elsewhere on the board
/FAN_TACH: RN1.7 (R2.2), U33.1 (IO1); also elsewhere on the board
/FLOW_TACH: R43.1, RN2.3 (R3.1), U33.4 (IO3); also elsewhere on the board
/NTC_ADC: C23.1, J6.1, R6.2, U33.5 (IO4); also elsewhere on the board
/PUMP_PWM: R16.2, R54.1; also elsewhere on the board
/PUMP_TACH: RN1.5 (R4.2), U33.3 (IO2); also elsewhere on the board
GND: C23.2, C76.2, C77.2, J3.1, J4.1, J5.1, J6.2, Q61.1 (S), Q61.4 (S), U33.2 (GND); also elsewhere on the board
unnamed: J3.3, RN1.1 (R1.1), RN1.2 (R2.1)
unnamed: J3.4, Q61.6 (D), RN2.1 (R1.1)
unnamed: J4.3, RN1.3 (R3.1), RN1.4 (R4.1)
unnamed: J4.4, Q61.3 (D), RN2.2 (R2.1)
unnamed: J5.3, R43.2
unnamed: Q61.2 (G), R53.2
unnamed: Q61.5 (G), R54.2

Notes on the sheet:
FLOW SENSOR
COOLANT NTC
SPARE 10k ELEMENT
Tach: open collector, 2 pulses/rev, counted with PCNT. Alphacool ES: tach -> GPIO18, NTC -> GPIO4.
PUMP
FAN
ESD CLAMP GROUND
Fan and pump: LEDC PWM at 25 kHz through one BSS138DW element each, because the PWM input can sit at 5.25 V (Intel 4-wire spec) and GPIOs are not 5 V tolerant. GPIO high = FET on = 0% drive; firmware inverts the duty.

Schematic: ldo_15v.kicad_sch, Regulators +-15V

Parts:
C57, C58, C59, C60: 22uF/25V X7R; C_1210_3225Metric
C81, C82: 1uF/50V; C_1206_3216Metric
R11, R12: 10k; R_0402_1005Metric
R74, R75: 432k; R_0402_1005Metric
R76, R77: 147k; R_0402_1005Metric
U21: LT3045EDD; DFN-10-1EP_3x3mm_P0.5mm_EP1.65x2.38mm
U22: LT3094HDD; DFN-12-1EP_3x3mm_P0.45mm_EP1.65x2.38mm

Connections:
+15V: C57.1, C59.1, R74.1, U21.9 (OUTS), U21.10 (OUT); also elsewhere on the board
+16V5: U21.1 (IN), U21.2 (IN), U21.3 (EN/UV); also elsewhere on the board
-15V: C58.1, C60.1, R75.1, U22.10 (OUTS), U22.11 (OUT), U22.12 (OUT); also elsewhere on the board
-16V5: U22.1 (IN), U22.2 (IN), U22.3 (EN/UV), U22.13 (IN); also elsewhere on the board
/PGN_15V: U22.4 (PG); also elsewhere on the board
/PGP_15V: U21.4 (PG); also elsewhere on the board
GND: C57.2, C58.2, C59.2, C60.2, C81.2, C82.2, R11.2, R12.2, R76.2, R77.2, U21.5 (ILIM), U21.8 (GND), U21.11 (GND), U22.6 (ILIM), U22.9 (GND); also elsewhere on the board
unnamed: R11.1, R74.2, U21.6 (PGFB)
unnamed: C81.1, R76.1, U21.7 (SET)
unnamed: R12.1, R75.2, U22.5 (PGFB)
unnamed: C82.1, R77.1, U22.8 (SET)

Notes on the sheet:
+15 V REGULATOR
PGFB dividers 432k/10k trip power good near 13.3 V (also enables fast start-up). Each open-collector PG pin goes to its node on the Power Good sheet.
LT3045 (+15 V) and LT3094 (-15 V) post-regulate the ADP5071 rails (+16.4 V / -16.5 V, Rails +-15V sheet) to +/-14.7 V: VOUT = 100 uA x RSET (147k; +15 V is the top of the LT3045 range).
-15 V REGULATOR

Schematic: io_switches.kicad_sch, IO Range and Pull-up

Parts:
C419, C420: 100nF; C_0402_1005Metric
R613, R614, R615, R616: 10k; R_0402_1005Metric
R617, R618, R619, R620, R621, R622, R623, R624: 100k; R_0402_1005Metric
U105: TMUX1111RSVR; UQFN-16_1.8x2.6mm_P0.4mm
U106: TMUX7412FRRPR; Texas_RUM0016A_WQFN-16-1EP_4x4mm_P0.65mm_EP2.6x2.6mm

Connections:
+3V3: R613.2, R614.2, R615.2, R616.2; also elsewhere on the board
+5V_IO: C419.1, U105.11 (VDD); also elsewhere on the board
+12V: C420.1, U106.11 (VDD); also elsewhere on the board
/Universal IO/IO1_DIRECT: R617.1, U105.15 (~SEL1); also elsewhere on the board
/Universal IO/IO1_DIV: U105.1 (S1); also elsewhere on the board
/Universal IO/IO1_PIN: U106.1 (S1); also elsewhere on the board
/Universal IO/IO1_PULLUP: R618.1, U106.15 (SEL1); also elsewhere on the board
/Universal IO/IO2_DIRECT: R619.1, U105.14 (~SEL2); also elsewhere on the board
/Universal IO/IO2_DIV: U105.12 (S2); also elsewhere on the board
/Universal IO/IO2_PIN: U106.12 (S2); also elsewhere on the board
/Universal IO/IO2_PULLUP: R620.1, U106.14 (SEL2); also elsewhere on the board
/Universal IO/IO3_DIRECT: R621.1, U105.7 (~SEL3); also elsewhere on the board
/Universal IO/IO3_DIV: U105.9 (S3); also elsewhere on the board
/Universal IO/IO3_PIN: U106.9 (S3); also elsewhere on the board
/Universal IO/IO3_PULLUP: R622.1, U106.7 (SEL3); also elsewhere on the board
/Universal IO/IO4_DIRECT: R623.1, U105.6 (~SEL4); also elsewhere on the board
/Universal IO/IO4_DIV: U105.4 (S4); also elsewhere on the board
/Universal IO/IO4_PIN: U106.4 (S4); also elsewhere on the board
/Universal IO/IO4_PULLUP: R624.1, U106.6 (SEL4); also elsewhere on the board
GND: C419.2, C420.2, R617.2, R618.2, R619.2, R620.2, R621.2, R622.2, R623.2, R624.2, U105.3 (GND), U105.5 (D4), U105.8 (D3), U105.13 (D2), U105.16 (D1), U106.2 (VSS), U106.3 (GND), U106.17 (EP); also elsewhere on the board
unnamed: R613.1, U106.16 (D1)
unnamed: R614.1, U106.13 (D2)
unnamed: R615.1, U106.8 (D3)
unnamed: R616.1, U106.5 (D4)

Notes on the sheet:
PULL-UP SWITCH, CHANNELS 1-4
Range: TMUX1111 closes while its select is low, grounding the 20k divider leg (0-15 V range). DIRECT high opens it. The switch only ever sees the ADC-side voltage, never the pin.
Pull-up: TMUX7412F on +12 V joins the pin to 10k / +3V3 while PULLUP is high. Its source pins block in both directions and survive +-60 V, so a pin above 3.3 V is not loaded while the switch is open. FF (fault flag) is not used.
RANGE SWITCH, CHANNELS 1-4
TMUX1111 DECOUPLING CAPACITORS
TMUX7412F DECOUPLING CAPACITORS

Schematic: io_ch2.kicad_sch, IO Channel 2

Parts:
C444, C447, C448: 100nF; C_0402_1005Metric
C445, C446: 1uF/50V; C_1206_3216Metric
D112: 1N4148W; D_SOD-123
D113, D114: TVS1800DRVR; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm
J37: IO2 (V+ / IO / GND / NC); XKB_X2510WRS-04-9TSN_1x04_P2.54mm_Horizontal
JP14: IO2 5V; R_0603_1608Metric
JP15: IO2 12V; R_0603_1608Metric; not fitted
Q102: CSD17381F4; Texas_FemtoFET_F4_1.0x0.6mm
R663, R673, R675: 100k; R_0402_1005Metric
R664: 20k; R_0402_1005Metric
R665: 120; R_2512_6332Metric
R666, R669: 1M; R_0402_1005Metric
R667, R668: 1k; R_0402_1005Metric
R670: 53.6k; R_0402_1005Metric
R671, R674: 10k; R_0402_1005Metric
R672: 22k; R_0402_1005Metric
U118: SN74LVC1G3157DSFR; Texas_DSF0006A_X2SON-6_1x1mm_P0.35mm
U119: SN74LVC1G125DRYR; Texas_USON-6_1x1.45mm_P0.5mm_SMD
U120: TPS26625DRCR; Texas_DRC0010J

Connections:
+3V3: C447.1, C448.1, D112.1 (K), R671.1, R674.1, U118.5 (VCC), U119.6 (VCC); also elsewhere on the board
+5V: JP14.1 (A); also elsewhere on the board
+12V: JP15.1 (A); also elsewhere on the board
/AUX_IO7: R667.2, R668.1; also elsewhere on the board
/Universal IO/IO2_ADC: C444.1, R663.2, R664.1; also elsewhere on the board
/Universal IO/IO2_BURDEN: Q102.1 (G), R673.1; also elsewhere on the board
/Universal IO/IO2_DAC: U118.1 (B2); also elsewhere on the board
/Universal IO/IO2_DIV: R664.2; also elsewhere on the board
/Universal IO/IO2_LEVEL: U118.4 (A); also elsewhere on the board
/Universal IO/IO2_PIN: D114.4 (IN), D114.5 (IN), D114.6 (IN), J37.2, R663.1, R665.1, R666.1; also elsewhere on the board
/Universal IO/IO2_SENS_EN: R672.1, U120.4 (~SHDN); also elsewhere on the board
/Universal IO/IO Channel 2/IO2_BUF: R667.1, U119.4 (Y)
/Universal IO/IO Channel 2/IO2_GATE: R668.2, R675.1, U118.6 (S)
/Universal IO/IO Channel 2/IO2_LOGIC: D112.2 (A), R666.2, U119.2 (A)
/Universal IO/~IO2_BUF_OE: R674.2, U119.1 (~OE); also elsewhere on the board
/Universal IO/~IO2_SENS_FLT: R671.2, U120.9 (~FLT); also elsewhere on the board
GND: C444.2, C445.2, C446.2, C447.2, C448.2, D113.1 (GND), D113.2 (GND), D113.3 (GND), D113.7 (GND), D114.1 (GND), D114.2 (GND), D114.3 (GND), D114.7 (GND), J37.3, Q102.2 (S), R670.2, R672.2, R673.2, R675.2, U118.2 (GND), U118.3 (B1), U119.3 (GND), U120.3 (OVP), U120.5 (RTN), U120.6 (GND), U120.11 (EP); also elsewhere on the board
unnamed: C446.1, D113.4 (IN), D113.5 (IN), D113.6 (IN), J37.1, U120.10 (OUT)
unnamed: C445.1, JP14.2 (B), JP15.2 (B), R669.1, U120.1 (IN)
unnamed: Q102.3 (D), R665.2
unnamed: R670.1, U120.7 (ILIM)
unnamed: R669.2, U120.2 (UVLO)

Notes on the sheet:
Input: the pin through 100k to the ADC; with the 20k leg grounded (default) 15 V reads 2.5 V, with DIRECT high the range is 0-2.5 V. BURDEN adds 120 R for 4-20 mA loops; PULLUP (range switch sheet) adds 10k to +3V3.
SENSOR SUPPLY AND CONNECTOR
GATE AND BUFFER DECOUPLING CAPACITORS
Every control line is pulled to its off level, so the channel is high impedance with the sensor supply off until firmware sets the expander. GPIO7 gates the DAC level (PWM) and reads the pin through the buffer.
Universal I/O channel 2: connector pin 1 = switched sensor supply, 2 = signal, 3 = GND. Output: DAC level x 4.83 from a TSB582 section through a switch (IO Output Drivers sheet), up to 100 mA, open while OUT_EN is low.
OUTPUT GATE (GPIO7)
FAST PATH (GPIO7)
MEASUREMENT

Schematic: io_expanders.kicad_sch, IO Expanders

Parts:
C421, C422: 100nF; C_0402_1005Metric
R625: 10k; R_0402_1005Metric
U107, U108: MCP23S17-E/ML; QFN-28-1EP_6x6mm_P0.65mm_EP4.25x4.25mm

Connections:
+3V3: C421.1, C422.1, R625.1, U107.5 (VDD), U108.5 (VDD), U108.11 (A0); also elsewhere on the board
/ESP_EN: U107.14 (~RESET), U108.14 (~RESET); also elsewhere on the board
/Universal IO/IO1_BURDEN: U107.19 (GPA2); also elsewhere on the board
/Universal IO/IO1_DIRECT: U108.2 (GPB5); also elsewhere on the board
/Universal IO/IO1_OUT_EN: U107.17 (GPA0); also elsewhere on the board
/Universal IO/IO1_PULLUP: U107.20 (GPA3); also elsewhere on the board
/Universal IO/IO1_SENS_EN: U107.21 (GPA4); also elsewhere on the board
/Universal IO/IO2_BURDEN: U107.27 (GPB2); also elsewhere on the board
/Universal IO/IO2_DIRECT: U107.26 (GPB1); also elsewhere on the board
/Universal IO/IO2_OUT_EN: U107.25 (GPB0); also elsewhere on the board
/Universal IO/IO2_PULLUP: U107.28 (GPB3); also elsewhere on the board
/Universal IO/IO2_SENS_EN: U107.1 (GPB4); also elsewhere on the board
/Universal IO/IO3_BURDEN: U108.19 (GPA2); also elsewhere on the board
/Universal IO/IO3_DIRECT: U108.18 (GPA1); also elsewhere on the board
/Universal IO/IO3_OUT_EN: U108.17 (GPA0); also elsewhere on the board
/Universal IO/IO3_PULLUP: U108.20 (GPA3); also elsewhere on the board
/Universal IO/IO3_SENS_EN: U108.21 (GPA4); also elsewhere on the board
/Universal IO/IO4_BURDEN: U108.27 (GPB2); also elsewhere on the board
/Universal IO/IO4_DIRECT: U108.26 (GPB1); also elsewhere on the board
/Universal IO/IO4_OUT_EN: U108.25 (GPB0); also elsewhere on the board
/Universal IO/IO4_PULLUP: U108.28 (GPB3); also elsewhere on the board
/Universal IO/IO4_SENS_EN: U108.1 (GPB4); also elsewhere on the board
/Universal IO/PREC_EXC_EN: U107.2 (GPB5); also elsewhere on the board
/Universal IO/~IO1_BUF_OE: U107.24 (GPA7); also elsewhere on the board
/Universal IO/~IO1_SENS_FLT: U107.23 (GPA6); also elsewhere on the board
/Universal IO/~IO2_BUF_OE: U107.4 (GPB7); also elsewhere on the board
/Universal IO/~IO2_SENS_FLT: U107.3 (GPB6); also elsewhere on the board
/Universal IO/~IO3_SENS_FLT: U108.23 (GPA6); also elsewhere on the board
/Universal IO/~IO4_SENS_FLT: U108.3 (GPB6); also elsewhere on the board
/Universal IO/~IO_OUT_FLT_A: U107.22 (GPA5); also elsewhere on the board
/Universal IO/~PREC_EXC_FLT: U108.22 (GPA5); also elsewhere on the board
/~EXP_INT: U108.4 (GPB7); also elsewhere on the board
/~IO_EXP_CS: U107.7 (~CS), U108.7 (~CS); also elsewhere on the board
/~IO_EXP_INT: R625.2, U107.15 (INTB), U107.16 (INTA), U108.15 (INTB), U108.16 (INTA); also elsewhere on the board
/~RS485_IRQ: U108.24 (GPA7); also elsewhere on the board
GND: C421.2, C422.2, U107.6 (VSS), U107.11 (A0), U107.12 (A1), U107.13 (A2), U107.29 (EP), U108.6 (VSS), U108.12 (A1), U108.13 (A2), U108.29 (EP); also elsewhere on the board
SPI_MISO: U107.10 (SO), U108.10 (SO); also elsewhere on the board
SPI_MOSI: U107.9 (SI), U108.9 (SI); also elsewhere on the board
SPI_SCK: U107.8 (SCK), U108.8 (SCK); also elsewhere on the board

Notes on the sheet:
Two MCP23S17 share ~{IO_EXP_CS}: hardware addresses 0 and 1 on A0 (A2 low on both, so one write of IOCON.HAEN reaches every device: errata DS80311A). Port A serves the odd channel of a pair, port B the even one.
7 ~{BUF_OE} (fast channels 1 and 2; the RS-485 and header interrupts on 3 and 4). All pins are inputs after reset, so the pull resistors on each line set the off state.
ADDRESS 0
ADDRESS 1
INTA and INTB must be set open drain (IOCON.ODR) before interrupts are enabled: all four share ~{IO_EXP_INT}, pulled up at address 0.
RESET on ESP_EN: an ESP32 reset also returns every channel to off.
Per port: bit 0 OUT_EN, 1 DIRECT (channel 1: on address 1 GPB5), 2 BURDEN, 3 PULLUP, 4 SENS_EN (outputs), 5 ~{OUT_FLT} (channel 1; elsewhere a spare), 6 ~{SENS_FLT} (inputs),
MCP23S17 DECOUPLING CAPACITORS

Schematic: io_core.kicad_sch, IO DAC and ADC

Parts:
C401, C402, C404, C405, C407, C409, C410: 100nF; C_0402_1005Metric
C403, C406, C408: 1uF; C_0603_1608Metric
U100: DAC60508ZRTER; Texas_RTE0016D_WQFN-16-1EP_3x3mm_P0.5mm_EP0.8x0.8mm
U101: ADS124S08IRHBR; Texas_RHB0032M_VQFN-32-1EP_5x5mm_P0.5mm_EP2.1x2.1mm

Connections:
+3V3: C404.1, C405.1, C406.1, C409.1, C410.1, U100.7 (VDD), U100.16 (VIO), U101.15 (IOVDD), U101.16 (DVDD), U101.18 (~RESET); also elsewhere on the board
+5V_IO: C407.1, C408.1, U101.26 (AVDD); also elsewhere on the board
/Universal IO/IO1_ADC: U101.7 (AIN0); also elsewhere on the board
/Universal IO/IO1_DAC: U100.2 (OUT0); also elsewhere on the board
/Universal IO/IO2_ADC: U101.6 (AIN1); also elsewhere on the board
/Universal IO/IO2_DAC: U100.3 (OUT1); also elsewhere on the board
/Universal IO/IO3_ADC: U101.5 (AIN2); also elsewhere on the board
/Universal IO/IO3_DAC: U100.4 (OUT2); also elsewhere on the board
/Universal IO/IO4_ADC: U101.4 (AIN3); also elsewhere on the board
/Universal IO/IO4_DAC: U100.5 (OUT3); also elsewhere on the board
/Universal IO/PREC_A_N: U101.21 (AIN9); also elsewhere on the board
/Universal IO/PREC_A_P: U101.22 (AIN8); also elsewhere on the board
/Universal IO/PREC_B_N: U101.19 (AIN11); also elsewhere on the board
/Universal IO/PREC_B_P: U101.20 (AIN10); also elsewhere on the board
/Universal IO/PREC_REFN: U101.29 (REFN0); also elsewhere on the board
/Universal IO/PREC_REFP: U101.30 (REFP0); also elsewhere on the board
/Universal IO/PRESS1_ADC: U101.3 (AIN4); also elsewhere on the board
/Universal IO/PRESS2_ADC: U101.2 (AIN5); also elsewhere on the board
/~IO_ADC_CS: U101.9 (~CS); also elsewhere on the board
/~IO_ADC_DRDY: U101.13 (~DRDY); also elsewhere on the board
/~IO_DAC_CS: U100.12 (~CS); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, U100.6 (GND), U100.17 (EP), U101.1 (AINCOM), U101.8 (START), U101.14 (DGND), U101.17 (CLK), U101.24 (REFCOM), U101.27 (AVSS), U101.28 (AVSS-SW), U101.33 (EP); also elsewhere on the board
unnamed: C401.1, C402.1, U100.1 (REF)
unnamed: C403.1, U101.23 (REFOUT)
SPI_MISO: U100.15 (SDO), U101.12 (DOUT); also elsewhere on the board
SPI_MOSI: U100.14 (SDI), U101.10 (DIN); also elsewhere on the board
SPI_SCK: U100.13 (SCLK), U101.11 (SCLK); also elsewhere on the board

Notes on the sheet:
AIN4 / AIN5 read the pressure ports against REFP0 / REFN0 (the 5 V excitation). AIN8-11 serve the precision ports. START and CLK low. DAC outputs 4-7 and AIN6 / AIN7 are not used.
INPUT ADC
DAC60508 DECOUPLING CAPACITORS
ADS124S08 AVDD DECOUPLING CAPACITORS
OUTPUT LEVEL DAC
ADS124S08 DVDD / IOVDD DECOUPLING CAPACITORS
ADS124S08: SPI mode 1, AVDD 5 V, logic 3.3 V. AIN0-3 read channels 1-4 against AINCOM = ground with the internal 2.5 V reference and the PGA bypassed (a ground-referenced input is outside the PGA range).
Both release their data output when CS is high (DAC60508 section 8.5, ADS124S08 section 9.5.1), so they share SPI_MISO without a buffer.
DAC60508Z: 12-bit, outputs at zero after reset. On 3.3 V its 2.5 V reference needs the divider on with gain 2 (GAIN register), giving 0-2.5 V; until firmware writes that, the reference alarm holds every output at 0 V. SDI is latched on falling SCLK edges (SPI mode 1).

Schematic: io_drivers.kicad_sch, IO Output Drivers

Parts:
C411, C412, C413, C414: 2pF/C0G; C_0402_1005Metric
C415, C416, C418: 100nF; C_0402_1005Metric
C417: 10uF/25V; C_1206_3216Metric
R600, R602, R604, R606: 49.9k; R_0402_1005Metric
R601, R603, R605, R607: 191k; R_0402_1005Metric
R608, R609, R610, R611: 100k; R_0402_1005Metric
R612: 10k; R_0402_1005Metric
U102, U103: TSB582IQ2T; DFN-8-1EP_3x3mm_P0.65mm_EP1.55x2.4mm
U104: TMUX7412FRRPR; Texas_RUM0016A_WQFN-16-1EP_4x4mm_P0.65mm_EP2.6x2.6mm

Connections:
+3V3: R612.1; also elsewhere on the board
+12V: C415.1, C416.1, C417.1, C418.1, U102.8 (V+), U103.8 (V+), U104.11 (VDD); also elsewhere on the board
/Universal IO/IO1_LEVEL: U102.3 (+); also elsewhere on the board
/Universal IO/IO1_OUT_EN: R608.1, U104.15 (SEL1); also elsewhere on the board
/Universal IO/IO1_PIN: U104.1 (S1); also elsewhere on the board
/Universal IO/IO2_LEVEL: U102.5 (+); also elsewhere on the board
/Universal IO/IO2_OUT_EN: R609.1, U104.14 (SEL2); also elsewhere on the board
/Universal IO/IO2_PIN: U104.12 (S2); also elsewhere on the board
/Universal IO/IO3_DAC: U103.3 (+); also elsewhere on the board
/Universal IO/IO3_OUT_EN: R610.1, U104.7 (SEL3); also elsewhere on the board
/Universal IO/IO3_PIN: U104.9 (S3); also elsewhere on the board
/Universal IO/IO4_DAC: U103.5 (+); also elsewhere on the board
/Universal IO/IO4_OUT_EN: R611.1, U104.6 (SEL4); also elsewhere on the board
/Universal IO/IO4_PIN: U104.4 (S4); also elsewhere on the board
/Universal IO/IO Output Drivers/IO1_DRV: C411.2, R601.2, U102.1, U104.16 (D1)
/Universal IO/IO Output Drivers/IO2_DRV: C412.2, R603.2, U102.7, U104.13 (D2)
/Universal IO/IO Output Drivers/IO3_DRV: C413.2, R605.2, U103.1, U104.8 (D3)
/Universal IO/IO Output Drivers/IO4_DRV: C414.2, R607.2, U103.7, U104.5 (D4)
/Universal IO/~IO_OUT_FLT_A: R612.2, U104.10 (~FF); also elsewhere on the board
GND: C415.2, C416.2, C417.2, C418.2, R600.1, R602.1, R604.1, R606.1, R608.2, R609.2, R610.2, R611.2, U102.4 (V-), U102.9 (PAD), U103.4 (V-), U103.9 (PAD), U104.2 (VSS), U104.3 (GND), U104.17 (EP); also elsewhere on the board
unnamed: C411.1, R600.2, R601.1, U102.2 (-)
unnamed: C412.1, R602.2, R603.1, U102.6 (-)
unnamed: C413.1, R604.2, R605.1, U103.2 (-)
unnamed: C414.1, R606.2, R607.1, U103.6 (-)

Notes on the sheet:
OUTPUT SWITCH DECOUPLING
CHANNELS 1-4
At 100 mA the pin sits about 1.5 V under the rail (0.55 V typ in the op amp, about 1 V in the 8-11 ohm switch). The ADC reads every pin, so firmware can check it. Channels 1 and 2 take their level from the GPIO gate on their own sheet.
TSB582 DECOUPLING
Output drivers: each TSB582 section multiplies its channel level by 1 + 191k / 49.9k = 4.83 (0-12 V from +12V). A TMUX7412F section joins it to the pin while OUT_EN is high. Feedback is taken ahead of the switch.
Open, the switch leaves only leakage on the pin. It also opens by itself when the pin is forced above +12V or below ground (FF goes low), so an outside source cannot feed the 12 V rail. Up to 100 mA per output: the switch rating (the op amp gives 150 mA min).
